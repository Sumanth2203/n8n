Commit message: Update robot.urdf

File: robot.urdf (robot description, URDF)
Before this commit: robot kuka_kr120r2500pro, 9 links, 8 joints
Joints:
- joint joint_a6-tool0: origin xyz=0.804 -0.12 0.02  rpy=0 -1.57079632679 -1.57079632679 -> xyz=0.215 0 0 rpy=0 1.57079632679 0
